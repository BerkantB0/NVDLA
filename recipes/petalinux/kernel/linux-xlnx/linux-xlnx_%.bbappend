FILESEXTRAPATHS:prepend := "${THISDIR}/linux-xlnx/files:"
SRC_URI:append = " file://nvdla-power-monitor.cfg"
